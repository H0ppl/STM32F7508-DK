# Keil uVision project STM32F7508-DK.uvprojx, settings and files
target STM32F7508-DK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F750N8Hx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x800FFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F7508-DK +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F750xx
  c include: ../Core/Inc;      ../TouchGFX/App;      ../TouchGFX/target/generated;      ../TouchGFX/target;      ../Drivers/STM32F7xx_HAL_Driver/Inc;      ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;      ../Middlewares/Third_Party/FreeRTOS/Source/include;      ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;      ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;      ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;      ../Drivers/CMSIS/Include;      ../Drivers/BSP/Components/Common;      ../Drivers/BSP/STM32F7508-Discovery;    ../middlewares/st/touchgfx/framework/include;    ../touchgfx/generated/fonts/include;    ../touchgfx/generated/gui_generated/include;    ../touchgfx/generated/images/include;    ../touchgfx/generated/texts/include;    ../touchgfx/gui/include
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\STM32F7508-DK.sct
  group Application/MDK-ARM
    ./: startup_stm32f750xx.s
    ./: bootloader.s
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: CortexMMCUInstrumentation.cpp TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group Drivers/BSP/STM32F7508-Discovery
    ../Drivers/BSP/STM32F7508-Discovery/: stm32f7508_discovery.c stm32f7508_discovery_sdram.c stm32f7508_discovery_ts.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/ft5336/: ft5336.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_dma2d.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group gui
    ../touchgfx/gui/src/graph_screen/graph_widget/: abstractgraph.cpp graph.cpp graphbelow.cpp graphdots.cpp graphline.cpp painterverticalalpha.cpp
    ../touchgfx/gui/src/customcontrols_screen/: circularprogress.cpp customcontrolspresenter.cpp customcontrolsview.cpp datepicker.cpp gauge.cpp threewayprogressbar.cpp threewayprogressbarcircle.cpp verticalslidemenu.cpp wheelselector.cpp wheelselectorextra.cpp
    ../touchgfx/gui/src/productpresenter_screen/: collapsiblemenu.cpp productpresenterpresenter.cpp productpresenterview.cpp
    ../touchgfx/gui/src/common/: dotindicator.cpp frontendapplication.cpp swipecontainer.cpp
    ../touchgfx/gui/src/easingequation_screen/: easingequationbutton.cpp easingequationgraph.cpp easingequationinoutselectorgroup.cpp easingequationpresenter.cpp easingequationselector.cpp easingequationview.cpp
    ../touchgfx/gui/src/graph_screen/: graphpresenter.cpp graphview.cpp legendentry.cpp piechart.cpp
    ../touchgfx/gui/src/mainmenu_screen/: mainmenupresenter.cpp mainmenuview.cpp
    ../touchgfx/gui/src/containers/: mculoadwidget.cpp
    ../touchgfx/gui/src/model/: model.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_asap_bold_otf_12_4bpp_0.cpp font_asap_bold_otf_15_4bpp_0.cpp font_asap_bold_otf_18_4bpp_0.cpp font_asap_bold_otf_18_4bpp_4.cpp font_asap_bold_otf_46_4bpp_0.cpp font_asap_regular_11_4bpp_0.cpp font_asap_regular_12_4bpp_0.cpp font_asap_regular_12_4bpp_4.cpp font_asap_regular_15_4bpp_0.cpp font_asap_regular_18_4bpp_0.cpp font_ipaexg_12_4bpp_0.cpp font_ipaexg_12_4bpp_10.cpp font_ipaexg_12_4bpp_11.cpp font_ipaexg_12_4bpp_12.cpp font_ipaexg_12_4bpp_13.cpp font_ipaexg_12_4bpp_14.cpp font_ipaexg_12_4bpp_15.cpp font_ipaexg_12_4bpp_16.cpp font_ipaexg_12_4bpp_17.cpp font_ipaexg_12_4bpp_18.cpp font_ipaexg_12_4bpp_6.cpp font_ipaexg_12_4bpp_9.cpp font_ipaexg_18_4bpp_0.cpp font_ipaexg_18_4bpp_17.cpp font_ipaexg_18_4bpp_6.cpp font_notosans_regular_12_4bpp_0.cpp font_notosans_regular_18_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_asap_bold_otf_12_4bpp.cpp kerning_asap_bold_otf_15_4bpp.cpp kerning_asap_bold_otf_18_4bpp.cpp kerning_asap_bold_otf_46_4bpp.cpp kerning_asap_regular_11_4bpp.cpp kerning_asap_regular_12_4bpp.cpp kerning_asap_regular_15_4bpp.cpp kerning_asap_regular_18_4bpp.cpp kerning_ipaexg_12_4bpp.cpp kerning_ipaexg_18_4bpp.cpp kerning_notosans_regular_12_4bpp.cpp kerning_notosans_regular_18_4bpp.cpp table_asap_bold_otf_12_4bpp.cpp table_asap_bold_otf_15_4bpp.cpp table_asap_bold_otf_18_4bpp.cpp table_asap_bold_otf_46_4bpp.cpp table_asap_regular_11_4bpp.cpp table_asap_regular_12_4bpp.cpp table_asap_regular_15_4bpp.cpp table_asap_regular_18_4bpp.cpp table_ipaexg_12_4bpp.cpp table_ipaexg_18_4bpp.cpp table_notosans_regular_12_4bpp.cpp table_notosans_regular_18_4bpp.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp
    ../touchgfx/generated/images/src/graph/: blue_area_button_active.cpp blue_area_button_inactive.cpp blue_dots_button_active.cpp blue_dots_button_inactive.cpp blue_line_button_active.cpp blue_line_button_inactive.cpp graph_background_bottom.cpp graph_menu_button.cpp graph_menu_button_pressed.cpp graph_toggle_button_active.cpp graph_toggle_button_inactive.cpp graph_top_menu_activate_button.cpp graph_top_menu_line.cpp green_area_button_active.cpp green_area_button_inactive.cpp green_dots_button_active.cpp green_dots_button_inactive.cpp green_line_button_active.cpp green_line_button_inactive.cpp half_circle_toggle_button_active.cpp half_circle_toggle_button_inactive.cpp new_graph.cpp new_graph_pressed.cpp new_pie_chart.cpp new_pie_chart_pressed.cpp pie_chart_legend_blue.cpp pie_chart_legend_blue_active.cpp pie_chart_legend_green.cpp pie_chart_legend_green_active.cpp pie_chart_legend_orange.cpp pie_chart_legend_orange_active.cpp pie_chart_legend_purple.cpp pie_chart_legend_purple_active.cpp pie_chart_legend_red.cpp pie_chart_legend_red_active.cpp pie_chart_legend_yellow.cpp pie_chart_legend_yellow_active.cpp pie_toggle_button_active.cpp pie_toggle_button_inactive.cpp
    ../touchgfx/generated/images/src/customcontrols/: control_center_button.cpp control_center_button_pressed.cpp control_color_wheel.cpp control_menu_arrow_down.cpp control_menu_arrow_down_inactive.cpp control_menu_arrow_down_pressed.cpp control_menu_arrow_up-inactive.cpp control_menu_arrow_up.cpp control_menu_arrow_up_pressed.cpp control_menu_button.cpp control_menu_button_pressed.cpp control_menu_icon_datepicker_large.cpp control_menu_icon_datepicker_small.cpp control_menu_icon_gauge_large.cpp control_menu_icon_gauge_small.cpp control_menu_icon_percentage_large.cpp control_menu_icon_percentage_small.cpp control_menu_icon_three_way_large.cpp control_menu_icon_three_way_small.cpp control_menu_shadow_bottom.cpp control_menu_shadow_top.cpp controls_background.cpp controls_menu_background.cpp controls_three_way_small_circle.cpp controls_wheel_background.cpp datepicker_bottom_shadow_overlay.cpp datepicker_glass_overlay.cpp datepicker_main_background.cpp datepicker_top_shadow_overlay.cpp gauge_background.cpp gauge_needle_pin.cpp small_circle_bin_icon_active.cpp small_circle_bin_icon_inactive.cpp small_circle_folder_icon_active.cpp small_circle_folder_icon_inactive.cpp small_circle_papers_icon_active.cpp small_circle_papers_icon_inactive.cpp
    ../touchgfx/generated/gui_generated/src/customcontrols_screen/: customcontrolsviewbase.cpp
    ../touchgfx/generated/images/src/mainmenu/: demo_button_01.cpp demo_button_01_pressed.cpp demo_button_02_03.cpp demo_button_02_03_pressed.cpp demo_button_04.cpp demo_button_04_pressed.cpp demo_button_05_06.cpp demo_button_05_06_pressed.cpp menu_demo_screen_02.cpp menu_demo_screen_03.cpp menu_demo_screen_04.cpp menu_demo_screen_05.cpp menu_stage_stretch_left_side.cpp menu_stage_stretch_right_side.cpp screen_swipe_dots_active.cpp screen_swipe_dots_inactive.cpp
    ../touchgfx/generated/images/src/easingequation/: easing_background.cpp easing_bottom_menu.cpp easing_bottom_menu_active.cpp easing_bottom_menu_selected.cpp easing_dot.cpp easing_menu_button.cpp easing_menu_button_pressed.cpp easing_side_menu_button.cpp easing_side_menu_button_active.cpp easing_side_menu_button_selected.cpp graphdot.cpp
    ../touchgfx/generated/gui_generated/src/easingequation_screen/: easingequationviewbase.cpp
    ../touchgfx/generated/images/src/productpresenter/: flag_dnk_active.cpp flag_dnk_inactive.cpp flag_gbr_active.cpp flag_gbr_inactive.cpp flag_jpn_active.cpp flag_jpn_inactive.cpp flag_nld_active.cpp flag_nld_inactive.cpp flag_ukr_active.cpp flag_ukr_inactive.cpp poster_image_00.cpp poster_image_01.cpp poster_image_02.cpp product_presenter_menu_button.cpp product_presenter_menu_button_pressed.cpp product_presenter_nav_bar.cpp product_presenter_next.cpp product_presenter_next_pressed.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/gui_generated/src/graph_screen/: graphviewbase.cpp
    ../touchgfx/generated/texts/src/: languagednk.cpp languagegbr.cpp languagejpn.cpp languagenld.cpp languageukr.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/mainmenu_screen/: mainmenuviewbase.cpp
    ../touchgfx/generated/gui_generated/src/containers/: mculoadwidgetbase.cpp
    ../touchgfx/generated/gui_generated/src/productpresenter_screen/: productpresenterviewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
software components: CMSIS:CORE 4.3.0
